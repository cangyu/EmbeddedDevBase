# IAR project EmbededBase.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RE ST STM32F103RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\BSP; ..\APP; ..\LIB\STM32_USB-FS-Device_Driver\inc; ..\LIB\STM32F10x_StdPeriph_Driver\inc; ..\FATFS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: EmbededBase.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: EmbededBase.bin
  group APP
    ../APP/: common.c download.c main.cpp upload.c ymodem.c
  group BSP
    ../BSP/: bsp.c bsp_ble.c bsp_btn.c bsp_led.c bsp_w25qxx.c stm32f10x_it.c system_stm32f10x.c
  group LIB/SPL
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    startup/: startup_stm32f103xe.s
